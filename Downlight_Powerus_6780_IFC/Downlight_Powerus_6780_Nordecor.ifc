Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-04-24T05:50:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 24 05:50:26 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\3691b408-fc60-4f48-8a8c-a3e7f06c3899\1910df4e-b5b6-4f82-8d07-0ffe2d4bf069\ifc * Database version: 5507 * Database creation date: Thu Apr 24 05:50:24 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 24 05:50:24 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 24 05:50:24 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328262
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6780 - Branco, Downlight_Powerus_6780_Nordecor_IFC:6780 - Branco:328262
In: Nível 1
Type - Material: LED, Metal - Alumínio - Branco, Plástico - Policarbonato - Translúcido
Type - Cotas - Altura da luminária: 48 mm; Comprimento da luminária: 46 mm; Largura da luminária: 46 mm
Type - Dados - Data da atualização: 18/04/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Downlight de embutir com borda, com acabamento e lente branca, LED 2W, 4000K 15º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Fixação: Molas; Garantia: 2 Anos; Grau de proteção: IP20; Localização: Camboriú-SC / Brasil; Modelo: 6780; Nome do tipo: 6780 - Branco; Número OmniClass: 23.80.70.11.14.14; Tipo de imagem: Imagem raster: 6780.png; Título OmniClass: Uplights; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/downlight-led-embutir-powerus-1-led-15o-2w-4-000k-irc90/
Type - Elétrico - Comentários de voltagem: 85-265V; Fator de potência - Luminária: 0.5; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Voltagem - Luminária: 0 V
Type - Estrutural - Peso: 0.095
Type - Fotométricos - Fluxo luminoso: 185 lm; Grau de abertura: 15 deg; IRC (RA): >90; Potência: 2 W; SDMC: <3; Temperatura de cor: 4000 K; UGR: <13
Type - Gráficos - Simbologia: Imagem raster: 6780 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - Policarbonato - Translúcido; Luminária: Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; 15°: yes; Branco: yes; Nome da família: Downlight_Powerus_6780_Nordecor_IFC
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Cotas - Área: 0.00548323 m2; Volume: 0.0000467943 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Downlight_Powerus_6780_Nordecor_IFC: 6780 - Branco; Família e tipo: Downlight_Powerus_6780_Nordecor_IFC: 6780 - Branco; ID de tipo: Downlight_Powerus_6780_Nordecor_IFC: 6780 - Branco; Tipo: Downlight_Powerus_6780_Nordecor_IFC: 6780 - Branco
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
